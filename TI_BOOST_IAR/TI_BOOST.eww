<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TI_ETAT_PWM\TI_ETAT_PWM.ewp</path>
    </project>
    <batchBuild />
</workspace>
